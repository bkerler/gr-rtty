options:
  parameters:
    author: Chris Kuethe
    category: Custom
    generate_options: qt_gui
    id: rtty_decode
    output_language: python
    run_options: run
    title: RTTY decoder example
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: bps
  id: variable
  parameters:
    value: '45.45'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.75'
    init: '0'
    low: '0.25'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: audio_rate*10
    type: float
  states: {}
- name: gr_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /tmp/rtty-out.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: gr_hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
    win: window.WIN_BLACKMAN
  states: {}
- name: gr_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(2*samp_rate/decimation)
    max_iter: int(samp_rate/decimation)
    scale: 1.0/(2*samp_rate/decimation)
    type: float
  states: {}
- name: gr_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '4'
  states: {}
- name: gr_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: gr_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/hydra/gnuradio/src/modules/gr-rtty/apps/rtty_audio.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: bps*3
    decim: decimation
    gain: '4'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: bps
    win: window.WIN_BLACKMAN
  states: {}
- name: n_gain
  id: note
  parameters:
    note: Adjust gain to get nice clean signal coming out of the LPF
  states: {}
- name: n_levels
  id: note
  parameters:
    note: adjust moving average and threshold to get clean 0/1 out
  states: {}
- name: n_ma
  id: note
  parameters:
    note: Keep product of length and scale close to 1
  states: {}
- name: n_rtty_bitstream
  id: note
  parameters:
    note: It may be necessary to flip the bitstream polarity
  states: {}
- name: note_0
  id: note
  parameters:
    note: Audio monitor is entirely unnecessary. Disable the audio sink and enable throttle+null to run in "fast forward" mode
  states: {}
- name: note_1
  id: note
  parameters:
    note: Test RTTY messages can be generated with fldigi
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '1024'
    name: '"avg_level"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '1024'
    name: '"analog_bits"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: '0'
    fftsize: '1024'
    name: '"bits"'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: audio_rate
    taps: ''
    type: fff
  states: {}
- name: rtty_decode_ff_0
  id: rtty_decode_ff
  parameters:
    baud_rate: bps
    polarity: 'False'
    samp_rate: samp_rate/decimation
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: audio_monitor
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: baseband
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: bits
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: filtered_audio
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: analog_bits
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: avg_level
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: audio_monitor
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: baseband
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: bits
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: filtered_audio
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: avg_level
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: bits
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: analog_bits
  states: {}

connections:
- [blocks_threshold_ff_0, '0', virtual_sink_2, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [gr_hilbert_fc_0, '0', gr_quadrature_demod_cf_0, '0']
- [gr_moving_average_xx_0, '0', gr_sub_xx_0, '1']
- [gr_moving_average_xx_0, '0', virtual_sink_5, '0']
- [gr_quadrature_demod_cf_0, '0', low_pass_filter_0, '0']
- [gr_sub_xx_0, '0', blocks_threshold_ff_0, '0']
- [gr_sub_xx_0, '0', virtual_sink_4, '0']
- [gr_wavfile_source_0, '0', virtual_sink_0, '0']
- [gr_wavfile_source_0, '0', virtual_sink_1, '0']
- [low_pass_filter_0, '0', gr_moving_average_xx_0, '0']
- [low_pass_filter_0, '0', gr_sub_xx_0, '0']
- [low_pass_filter_0, '0', virtual_sink_3, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle_0, '0']
- [rtty_decode_ff_0, '0', gr_file_sink_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0, '0']
- [virtual_source_1, '0', gr_hilbert_fc_0, '0']
- [virtual_source_2, '0', rtty_decode_ff_0, '0']
- [virtual_source_3, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_4, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_5, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [virtual_source_6, '0', qtgui_freq_sink_x_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-55-g8526e6f8
